# Keil uVision project STANDBY.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xieyi +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\xieyi;..\HARDWARE\KEY;..\HARDWARE\RTC;..\HARDWARE\W25Q64\FLASH;..\HARDWARE\W25Q64\SPI;..\SYSTEM\delay;..\HARDWARE\SHT20
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/W25Q64/FLASH/: flash.c
    ../HARDWARE/W25Q64/SPI/: spi.c
    ../HARDWARE/SHT20/: i2c.c sht20.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_spi.c
  group README
    ../: README.TXT
  group xieyi
    ../HARDWARE/xieyi/: xieyi.c xieyi_config.c
  group TXT
    ../: README.TXT
